options:
  parameters:
    generate_options: qt_gui
    id: QAM4_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '800'
  states: {}
- name: qam4_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/belenko/Projects/test_file_received.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/belenko/Projects/test_file_source.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: symb_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam4_constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam4_constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '10'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: bit_rate/2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: bit_rate/2
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '10'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: bit_rate
    type: fir_filter_ccf
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_int_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_complex_to_float_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', digital_constellation_decoder_cb_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
